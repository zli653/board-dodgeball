# Keil uVision project proj.uvprojx, settings and files
target proj (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: ece353_base_project
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --debug
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\3.20.4\CMSIS\Include;..\include;..\drivers\include;..\peripherals\include
  asm misc: --debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c main.h
  group drivers
    ../drivers/c/: gpio_port.c uart.c timers.c spi.c pc_buffer.c i2c.c adc.c
    ../drivers/include/: gpio_port.h
  group peripherals
    ../peripherals/c/: lcd.c wireless.c ws2812b_ice.c spi_select.c serial_debug0.c serial_debug.c ps2.c lcd_images.c launchpad_io.c io_expander.c ft6x06.c eeprom.c ece353_images.c accel.c
    ../peripherals/include/: lcd.h wireless.h
    ./: hw2_images.c hw2_images.h
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
